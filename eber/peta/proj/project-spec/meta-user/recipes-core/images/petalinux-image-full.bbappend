#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " motor-start"
IMAGE_INSTALL_append = " motor-set"
IMAGE_INSTALL_append = " eber-run"
